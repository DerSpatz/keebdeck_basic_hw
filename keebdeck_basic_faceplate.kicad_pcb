File: keebdeck_basic_faceplate.kicad_pcb (KiCad board)
At the start: 2 copper layers, 87.4 x 67.6 mm, 12 parts

Commit message: Rev 1.1 - Production
Other:
- outline, holes or cut-outs redrawn
